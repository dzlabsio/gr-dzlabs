<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>udp_sink</value></param>
<param><key>author</key><value>DZ Labs, LLC</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>UDP Sink</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>dzlabs_udp_sink</key>
<param><key>id</key><value>dzlabs_udp_sink_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>length_tag</key><value></value></param>
<param><key>port</key><value>1234</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>dzlabs_udp_sink_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
</flow_graph>
